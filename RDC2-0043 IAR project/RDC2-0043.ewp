# IAR project RDC2-0043.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F042K6 ST STM32F042K6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F042x6
  ICCARM.CCIncludePath2: Inc; STM32_USB_Device_Driver\inc; STM32_USB_Device_Library\Core\inc; STM32_USB_Device_Library\Class\hid\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RDC2-0043.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group STM32F0_USB_Device_Library/Class/HID
    STM32_USB_Device_Library/Class/hid/src/: usbd_custom_hid_core.c
  group STM32F0_USB_Device_Library/Driver
    STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32F0_USB_Device_Library/Library
    STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group system
    Src/: startup_stm32f042.s system_stm32f0xx.c
  group user
    Src/: ADC.c DataTables.c Display.c LED.c main.c Output.c RDC2-0043_USB.c SPI_EEPROM.c stm32f0xx_it.c Thermistor.c usb_bsp.c usbd_desc.c usbd_pwr.c usbd_usr.c UserCtrl.c
